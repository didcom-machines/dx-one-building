FILESEXTRAPATHS := "${THISDIR}/files:${FILESEXTRAPATHS}"
SRC_URI += " \
    file://enable_lvds1_u-boot.patch \
"